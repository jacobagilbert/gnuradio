options:
  parameters:
    author: J. Gilbert
    copyright: J. Gilbert
    description: Use of PDU Lambda block
    generate_options: qt_gui
    id: pdu_lambda_chirp_demo
    output_language: python
    title: PDU Lambda Chirp Demo
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 1024*4
  states: {}
- name: k
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0.1'
    step: '0.01'
    stop: '2'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: vec
  id: variable
  parameters:
    value: pmt.init_f32vector(N, np.arange(N))
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, vec)
    period: '250'
  states: {}
- name: demod_time_sink
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    srate: samp_rate
    type: msg_float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: note
  id: note
  parameters:
    comment: |-
      This flowgraph will generate and transmit random up or down
      chirps from a USRP using PDU Lambda and the PDU to Stream
      blocks. It is not intended to be a practical example, but it can be
      relatively easily modified to transmit meaningful signals.
    note: Flowgraph Summary
  states: {}
- name: pdu_lambda1
  id: pylambda_pdu_lambda
  parameters:
    comment: Generate Random Chirp
    fn: 'lambda x: k * np.complex64(np.exp(2*np.pi * 1j  * x * x * (0.05 * (np.random.randint(40)-19.5) / len(x)) ))'
    key: pmt.intern("key")
    metadict: Uniform Vector
  states: {}
- name: pdu_lambda2
  id: pylambda_pdu_lambda
  parameters:
    comment: Frequency Demod
    fn: 'lambda x: np.float32(np.unwrap(np.angle(x[1:]) - np.angle(x[:-1])))'
    key: pmt.intern("key")
    metadict: Uniform Vector
  states: {}
- name: pdu_pdu_to_stream_X_0
  id: pdu_pdu_to_stream_X
  parameters:
    depth: '64'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {}
- name: stream_time_sink
  id: qtgui_time_sink_x
  parameters:
    size: N*2
    srate: samp_rate
    type: complex
  states: {}
- name: time_sink
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    srate: samp_rate
    type: msg_complex
  states: {}
- name: uhd_sink
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 915e6
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '128'
    gui_hint: 0,0,2,1
    type: msg_complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_lambda1, pdu]
- [pdu_lambda1, pdu, pdu_lambda2, pdu]
- [pdu_lambda1, pdu, pdu_pdu_to_stream_X_0, pdus]
- [pdu_lambda1, pdu, time_sink, in]
- [pdu_lambda1, pdu, waterfall, in]
- [pdu_lambda2, pdu, demod_time_sink, in]
- [pdu_pdu_to_stream_X_0, '0', stream_time_sink, '0']
- [pdu_pdu_to_stream_X_0, '0', uhd_sink, '0']

metadata:
  file_format: 1
