options:
  parameters:
    author: J. Gilbert
    copyright: 2021 J. Gilbert
    description: Simple example of generating periodic bursts from PDUs
    generate_options: qt_gui
    id: simple_pdu_to_stream_example
    output_language: python
    title: Simple PDU To Stream Example
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: v
  id: variable
  parameters:
    value: pmt.init_c32vector(N,np.arange(N).tolist())
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL, v)
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/N
    type: complex
  states: {}
- name: imp
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note
  id: note
  parameters:
    comment: |-
      This is a simple example showing how the PDU to Stream block can
      convert PDU data to streaming data for transmission from a SDR
      such as a USRP including the addition of appropriate stream tags.
    note: Flowgraph Summary
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("tx_time")
    v: pmt.make_tuple(pmt.from_uint64(1),pmt.from_double(0.1234))
  states: {}
- name: pdu_pdu_to_stream_X_0
  id: pdu_pdu_to_stream_X
  parameters:
    depth: '64'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: N*2
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_pdu_set_0, pdus]
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [pdu_pdu_set_0, pdus, pdu_pdu_to_stream_X_0, pdus]
- [pdu_pdu_to_stream_X_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
